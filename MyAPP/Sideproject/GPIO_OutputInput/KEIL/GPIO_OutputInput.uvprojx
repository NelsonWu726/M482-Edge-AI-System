# Keil uVision project GPIO_OutputInput.uvprojx, settings and files
target GPIO_OutputInput (6240000::V6.24::ARMCLANG)
  device: M482LE8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.11
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: GPIO_OutputInput
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\..\tflm_tree;..\..\..\..\tflm_tree\third_party\flatbuffers\include;..\..\..\..\tflm_tree\third_party\gemmlowp;..\..\..\..\tflm_tree\third_party;..\..\..\..\tflm_tree\third_party\ruy;.\USB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c gpio.c clk.c sys.c uart.c timer.c epwm.c eadc.c fmc.c usbd.c
  group TFLM
    ../../../../tflm_tree/tensorflow/lite/micro/: micro_interpreter.cc micro_interpreter_context.cc micro_interpreter_graph.cc micro_allocator.cc micro_allocation_info.cc memory_helpers.cc micro_resource_variable.cc micro_op_resolver.cc micro_log.cc micro_utils.cc flatbuffer_utils.cc micro_profiler.cc micro_context.cc debug_log.cc micro_time.cc
    ../../../../tflm_tree/tensorflow/lite/micro/arena_allocator/: non_persistent_arena_buffer_allocator.cc persistent_arena_buffer_allocator.cc single_arena_buffer_allocator.cc
    ../../../../tflm_tree/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc linear_memory_planner.cc
    ../../../../tflm_tree/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.cc micro_error_reporter.cc
    ../../../../tflm_tree/tensorflow/lite/core/api/: flatbuffer_conversions.cc
    ../../../../tflm_tree/tensorflow/lite/core/c/: common.cc
    ../../../../tflm_tree/tensorflow/lite/micro/kernels/: kernel_util.cc expand_dims.cc conv.cc reshape.cc reduce.cc fully_connected.cc conv_common.cc reshape_common.cc reduce_common.cc fully_connected_common.cc logistic.cc logistic_common.cc
    ../../../../tflm_tree/tensorflow/compiler/mlir/lite/schema/: schema_utils.cc
    ../../../../tflm_tree/tensorflow/compiler/mlir/lite/core/api/: error_reporter.cc
    ../../../../tflm_tree/tensorflow/lite/kernels/internal/: portable_tensor_utils.cc tensor_ctypes.cc quantization_util.cc
    ../: tflite_internal_common.cc tflite_kernel_util.cc
  group Tasks
    ./: max30102_task.c network_task.c output_task.c inference_task.c sensor_task.c
  group App
    ./: app_queue.c app.c
    ../: main.c
  group Drivers
    ./: bh1750.c timer1.c buzzer.c lcd1602.c max30102.c wifi.c myi2c.c adc.c app_uart.c wifi_secrets.example.h
  group AI
    ./: peak.c spo2_algorithm.c model_data.c ai_model.cpp
  group USB
    ./: descriptors.c hid_mousekeyboard.c usb_hid_port.c hid_mousekeyboard.h usb_hid_task.c
  group System
    ../../../../examples/: hclk.c
    ./: systick.c
  group Diagnostics
    ./: test.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:Startup 0.00.001
